# Keil uVision project 03_Water_Tds_Level_Register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\02_arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_LED_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\driver\usart;.\common\debug;.\driver\fsmc;.\inf\lcd;.\app\display;.\common\delay;.\driver\gpio;.\inf\hx710;.\app\water_level;.\driver\spi;.\inf\w25q32;.\app\tds;.\inf\ads1115;.\driver\i2c
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c
  group App
    ./app/display/: App_Display.c
    ./app/water_level/: App_WaterLevel.c
    ./app/tds/: App_Tds.c
  group Inf
    ./inf/lcd/: Inf_LCD.c
    ./inf/hx710/: Inf_HX710.c
    ./inf/w25q32/: Inf_W25Q32.c
    ./inf/ads1115/: ads1115.c
  group Driver
    ./driver/usart/: Driver_USART1.c
    ./driver/fsmc/: Driver_FSMC.c
    ./driver/gpio/: Driver_GPIO.c
    ./driver/spi/: Driver_SPI.c
    ./driver/i2c/: Driver_I2C2.c
  group Common
    ./common/debug/: Common_Debug.c
    ./common/delay/: Common_Delay.c
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
